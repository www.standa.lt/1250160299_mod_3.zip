# Autodesk Inventor part: 8MBM57-6
## iProperties
Created: 2009-08
Part Number: 8MBM57-6
Document SubType Name: Modeling
Designer: Darius
Author: Darius
